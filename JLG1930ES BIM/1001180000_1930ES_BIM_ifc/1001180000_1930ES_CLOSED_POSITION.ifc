Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-03-19T12:03:53
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Mar 19 12:03:53 2018 * Host: CHTSP10141 * Database: C:\Users\20062089\AppData\Local\Temp\{68AC3693-5013-4650-BCD4-07FD4959F178}\ifc * Database version: 5507 * Database creation date: Mon Mar 19 12:03:45 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Mar 19 12:03:46 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Mar 19 12:03:46 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Graphics - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm

# IfcTransportElement: 1001180000_1930ES, 1001180000_1930ES:1001180000_1930ES:1192971
In: Level 1
Type - PredefinedType: ELEVATOR; Material: JLG_Paint_Orange, JLG_Paint_Black, JLG_Plastic_Red, JLG_Paint_White, JLG_Paint_Beige, JLG_Rubber_Light Grey, JLG_Metal Paint_Black, JLG_Metal Paint_White
Type - Constraints - EXT: 0 mm; Height: -583 mm; Ht: 306 mm; Offset: 889 mm; Platform_Height: 0 mm; Platform Extension: 0 mm; Platform Extension Maximum: User to define Extension; Platform Height Maximum: User to define Height; Platform Length: 1809 mm; PX: 0 mm; Static: 583 mm; Transportation Condition: no
Type - Data - Deep Cycle Batteries: 220A-HR, 6V x4; Drive: 24V DC Shunt Wound; Drive Speed elevated: 0.98 kph (0.61 mph); Drive Speed lowered: 4.90 kph (3.04 mph); Gradeability: 25%; Gross Vehicle Weight (ANSI): 1327 kg (2925 lbs); Gross Vehicle Weight (CE): 1603kg (3535 lbs); Ground Clearance: 0.089 m ( 0 ft 3.5 in); Hydraulic system: 122 L (32 gal); Lift Up time: 18 sec; Lower down Time: 22 sec; Max Ground Bearing Pressure (ANSI): 8.73kg/cm2 (124.17 psi); Max Ground Bearing Pressure (CE): 8.73kg/cm2 (124.17 psi); Platform Capacity (ANSI): 227 kg (500 lbs); Platform Capacity (CE): 227 kg (500 lbs); Platform Extension Size: 0.96m (3 ft 2 in); Platform Extention Capacity (ANSI): 113 kg (250 lbs); Platform Extention Capacity (CE): 113 kg (250 lbs); Platform Height: 5.70 m (18 ft 8 in); Platform Size: 0.76 m x 1.87 m (2 ft 6 in x 6 ft 2 in); Turning Radius Inside: 0 m; Turning Radius Outside: 1.75 m (5 ft 9 in); Tyres: 100x323 non-marking
Type - General - Electric Scissor Lift: 1930ES; Platform Extension Size ( L): 0.96m (3 ft 2 in); Platform Size (W x L): 0.76 m x 1.87 m (2 ft 6 in x 6 ft 2 in)
Type - Identity Data - Manufacturer: JLG; OmniClass Number: 23.40.00.00; OmniClass Title: Equipment and Furnishings; Type Name: 1001180000_1930ES; URL: www.jlg.com
Type - Model Properties - _Author: n/a; _AuthorizedBy: n/a; _BIMspec_GUID: n/a; _BimSpecGuid: n/a; _BSBibleVersion: n/a; _CreatedBy: JLG; _CurrentRevision: 0; _DistributedBy: JLG; BIMObjectName: 1001180000_1930ES; NBSDescription: Electric Scissor Lift; NBSNote: n/a; NBSObjectName: JLG_1930ES_Scissor Lift; NBSOfficeMasterTag: n/a; NBSReference: n/a
Type - Other - Category: Mechanical Equipment; AccessibilityPerformance: n/a; AssetIdentifier (default): Please Record On Commissioning; AssetType: Elevators; BarCode (default): Please Record On Commissioning; ClassificationName: n/a; ClassificationValue: n/a; CodePerformance: n/a; Color: n/a; Constituents: n/a; CreatedBy: JLG (https://www.jlg.com/en); CreatedOn: 2018; DocumentationCertificates: n/a; DocumentationInstallationGuide: n/a; DocumentationLiterature: n/a; DocumentationMaintenance: n/a; DocumentationTechnical: n/a; DurationUnit: Years; ExpectedLife: n/a; Family Name: 1001180000_1930ES; Features: n/a; Finish: n/a; Grade: n/a; InstallationDate (default): n/a; ManufacturerName: JLG (https://www.jlg.com/en); Material: n/a; ModelNumber: 1930ES; ModelReference: JLG_Electric Scissor Lift; ProductionYear: n/a; ReferencedStandard: n/a; ReplacementCost: n/a; SerialNumber (default): Please Record On Commissioning; Shape: n/a; Size: n/a; SpareParts: n/a; TypeName: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Years; WarrantyGuarantorLabor: https://www.jlg.com; WarrantyGuarantorParts: https://www.jlg.com
OperationType: ELEVATOR; CapacityByWeight: 0 kg; CapacityByNumber: 0
Pset_ManufacturerTypeInformation - ModelReference: JLG_Electric Scissor Lift; Manufacturer: JLG; ProductionYear: n/a
Constraints - BWA: no; Extension Working Area: no; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm; Turning Radius: no; Working Area: no
Dimensions - Area: 62.8015 m2; Volume: 0.300197 m3
Identity Data - Mark: 52
Other - Family: 1001180000_1930ES: 1001180000_1930ES; Family and Type: 1001180000_1930ES: 1001180000_1930ES; Type: 1001180000_1930ES: 1001180000_1930ES; Type Id: 1001180000_1930ES: 1001180000_1930ES; WarrantyStartDate (default): Please Record On Commissioning
Phasing - Phase Created: Phase 1
